# Keil uVision project led_board.uvproj, settings and files
target led_board (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: led_board +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group startup
    ./: STARTUP.A51
  group src
    ./src/: main.c i2c.c poe_m.c timer.c tt9980.c uart.c
